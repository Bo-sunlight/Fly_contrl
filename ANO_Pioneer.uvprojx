# Keil uVision project ANO_Pioneer.uvprojx, settings and files
target Ano_Pioneer (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ANO_Pioneer +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c misc: --c99
  c include: .\build;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\USBStack\INC;.\Libraries\FatFS\src;.\SRC\applications;.\SRC\drivers;.\SRC\fc_general;.\SRC\fc_specific;.\Libraries\VL53L0X\inc;.\User;.\SRC\openmv_data
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: User_Func.c User_tasks.c
    ./SRC/openmv_data/: openmv_data.c
  group applications
    ./SRC/applications/: main.c include.h Ano_Scheduler.c BSP_Init.c Ano_DT.c Ano_RC.c Ano_OF.c stm32f4xx_conf.h stm32f4xx_it.c Ano_USB.c usb_config.c Ano_FlyCtrl.c
  group fc_general
    ./SRC/fc_general/: Ano_FcData.c Ano_Filter.c Ano_Imu.c Ano_Math.c Ano_MotionCal.c Ano_Navigate.c Ano_Pid.c
  group fc_specific
    ./SRC/fc_specific/: config.h Ano_AltCtrl.c Ano_AttCtrl.c Ano_FlightCtrl.c Ano_LocCtrl.c Ano_MagProcess.c Ano_MotorCtrl.c Ano_Power.c Ano_FlightDataCal.c
  group drivers
    ./SRC/drivers/: Drv_led.c Drv_adc.c Drv_spi.c Drv_pwm_in.c Drv_pwm_out.c Drv_time.c Drv_usart.c Drv_ak8975.c Drv_icm20602.c Drv_spl06.c Drv_vl53l0x.c Drv_w25qxx.c Drv_i2c_soft.c usbd_STM32F4xx_FS.c Drv_gps.c Drv_heating.c Drv_sbus.c Drv_sbus.h
    ./SRC/applications/: Ano_Parameter.c
  group Libraries
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group USBStack
    ./Libraries/USBStack/SRC/: usbd_core.c usbd_core_hid.c usbd_hid.c
  group Vl53l0x
    ./Libraries/VL53L0X/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_i2c.c vl53l0x_platform.c
  group Note
    ./doc/: note.txt
    ./: 更新记录.txt
